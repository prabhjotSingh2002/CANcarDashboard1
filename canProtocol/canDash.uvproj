# Keil uVision project canDash.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RXnode +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s header.h mainNodeA.c mainNodeB.c debug.ini candriver.c
    ../spi/: timer.c uart0driver.c lcddriver.c
    ../adc-temp/: adcdriver.c
    ../i2c/: externalinterrupt2.c externalinterrupt1.c externalinterrupt0.c
